## hw3/dz2/conf/local.conf
```bitbake
[project]
SECRET_KEY = 'django-insecure-*a&)ax+cdj6dk$-v4qxb@)44%p@4&yxpr_psn-o9a5fc=%+o5('
```
